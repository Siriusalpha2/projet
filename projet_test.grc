<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tutorial_two_1</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabQT</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Time</value></param>
<param><key>label1</key><value>Frequency</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>tabQT@1</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>gui_hint</key><value>tabQT@0</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_1</value></param>
<param><key>file</key><value>/home/raph/projet/BreathingInMask.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_3</value></param>
<param><key>file</key><value>/home/raph/projet/desert.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_2</value></param>
<param><key>file</key><value>/home/raph/projet/seabattle_loop.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/raph/projet/jungle.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>frequency</value></param>
<param><key>amp</key><value>0.1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>5</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>radio</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>radio</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>Cosinus signal</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Jungle</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>label2</key><value>Breathe</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>label3</key><value>Desert</value></param>
<param><key>option4</key><value>4</value></param>
<param><key>label4</key><value>Battle</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>start</key><value>20</value></param>
<param><key>stop</key><value>20000</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_1</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_3</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_2</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
